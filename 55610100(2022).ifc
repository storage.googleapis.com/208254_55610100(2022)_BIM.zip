Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-28T13:03:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 28 13:03:26 2022 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\{56328174-33B5-442B-88E3-1CF68585C85B}\ifc * Database version: 5507 * Database creation date: Mon Nov 28 13:03:24 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 28 13:03:25 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 28 13:03:25 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 55610100 Hand shower, 55610100(2022):55610100 Hand shower:422743
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 56.5246 mm; NominalHeight: 217.441 mm; NominalWidth: 90 mm
Type - General - Author: BIMStone; BIMObjectName: 55610100(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 23/11/2022
Type - Green Building Properties - EAN Number: 4057304019104; EN Standard: EN 1112; ETIM Class Number: EC010161 Hand shower; Sales Package dimensions (LxWxH): 235 x 110 x 45; UNSPSC Class Number: 30181803 Hand held shower unit; URL Declaration of Conformity: http://static.hansa.com/DoC/55610100; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/55610100; 3D View: https://static.hansa.com/AR/55610100; Catalog Drawing URL: http://static.hansa.com/catdrw/55610100; Dimension Drawing URL: http://static.hansa.com/dimdrw/55610100; FDV Document URL: http://www.hansa.com/datasheet/55610100/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/55610100; Group: Hand shower; Installation and Maintenance Guide URL: http://static.hansa.com/manual/55610100; Interactive AR View URL: https://static.hansa.com/AR/55610100; Manufacturer: HANSA; Market: International;Germany; Mobile Product Information URL: http://mpi.hansa.com/55610100; Model: 55610100 Hand shower; Name_en: 55610100 Hand shower; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 55610100; Product Family: 5160; Product Image URL: http://static.hansa.com/image/55610100; Product URL: http://static.hansa.com/55610100; Technical DataSheet URL: http://www.hansa.com/datasheet/55610100/en; Type Name: 55610100 Hand shower; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa: 0.0116538 m3/s; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Anti limescale technology (easy to clean); Shower Spray: Refreshing; Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 55610100(2022); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 55610100; Name: 55610100 Hand shower; ReplacementCost: n/a; Shape: Sculptured; Size: 90x55x220 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 55610100; Manufacturer: HANSA
Pset_DistributionFlowElementCommon - Reference: 55610100 Hand shower
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0369477 m2; Volume: 0.00110617 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 55610100(2022): 55610100 Hand shower; Family and Type: 55610100(2022): 55610100 Hand shower; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 55610100(2022): 55610100 Hand shower; Type Id: 55610100(2022): 55610100 Hand shower; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
